# IAR project CrabVMS.ewp, settings and files
configuration CrabBoard (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F4; STM32F411xE; CRABMEM_STATIC; USE_HSE_BYPASS; USE_STDPERIPH_DRIVER; USE_USB_OTG_FS; USB_OTG_FS_QUALIFIER
  ICCARM.CCIncludePath2: ..\SYSTEM\Include; ..\SYSTEM\StartUp; ..\HARDWARE\eeprom; ..\HARDWARE\spi_flash; ..\HARDWARE\nRF24; ..\HARDWARE\usb; ..\HARDWARE; ..\HARDWARE\Stm32; ..\Platform; ..\APP; ..\RTOS; ..\RTOS\FreeRTOS\include; ..\RTOS\FreeRTOS\portable\IAR\ARM_CM4F; ..\Core\Inc; ..\Core\Port; ..\GAP; ..\ST\USB\Device\inc; ..\ST\USB\Driver\inc; ..\ST\StdPeriph\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\RTOS
  OBJCOPY.OOCOutputFile: CrabVMS.hex
  ILINK.IlinkOutputFile: CrabVMS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Crab-Lib
    ../Core/Lib/: Crab.Core.Lite.CM4F.a
  group Crab-Lib/inc
    ../Core/Inc/: CrabBaseType.h CrabErrorMsg.h CrabExecute.h CrabExtern.h CrabFifo.h CrabMath.h CrabStream.h CrabString.h CrabUtility.h
  group Crab-Lib/port
    ../Core/Port/: CrabConfig.h CrabPlatform.h
  group Crab-Platform/inc
    ../Platform/: CrabHardware.h CrabStorage.h CrabStoreStream.h CrabVersionFW.h CrabVMS.h
  group Crab-Platform/src
    ../Platform/: CrabApplication.c CrabBoardApi.c CrabClock.c CrabCommand.c CrabEvent.c CrabHardware.c CrabPortable.c CrabStaticApi.c CrabStorage.c CrabStoreStream.c CrabSystem.c CrabTask.c CrabVMS.c
  group FreeRTOS
    ../RTOS/: FreeRTOSConfig.h
  group FreeRTOS/inc
    ../RTOS/FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/port
    ../RTOS/FreeRTOS/portable/MemMang/: heap_3.c
    ../RTOS/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group FreeRTOS/src
    ../RTOS/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group GAP
    ../GAP/: Gap.c Gap.h
  group HARDWARE
    ../Hardware/: Hardware.c Hardware.h stm32f4xx_it.c stm32f4xx_it.h
  group HARDWARE/eeprom
    ../Hardware/eeprom/: eeprom.c eeprom.h eepromCfg.h
  group HARDWARE/nRF24
    ../Hardware/nRF24/: nRF24L01.c nRF24L01.h nRF24L01Cfg.h
  group HARDWARE/spi_flash
    ../Hardware/spi_flash/: spiflash.c spiflash.h spiflashCfg.h
  group HARDWARE/stm32ext
    ../Hardware/stm32/: stm32ext.c stm32ext.h stm32gpio.h
  group HARDWARE/USB/core
    ../ST/USB/Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../ST/USB/Device/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group HARDWARE/USB/inc
    ../ST/USB/Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
    ../ST/USB/Device/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group HARDWARE/USB/usr
    ../Hardware/usb/: usb_bsp.c usb_conf.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_gap.c usbd_gap.h usbd_hw_init.c
  group ST-LIBRARIES/inc
    ../ST/StdPeriph/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group ST-LIBRARIES/src
    ../ST/StdPeriph/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM/START UP
    ../System/StartUp/: startup_stm32f40xx.s startup_stm32f4xx.s
  group SYSTEM/STM32-M4
    ../System/Include/: core_cm4.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
    ../System/Source/: system_stm32f4xx.c
