# IAR project CrabVMS.ewp, settings and files
configuration CR4101 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F4; STM32F411xE; CRABMEM_STATIC; USE_HSE_BYPASS; USE_STDPERIPH_DRIVER; USE_USB_OTG_FS; USB_OTG_FS_QUALIFIER; CRABBOARD
  ICCARM.CCIncludePath2: ..; ..\SYSTEM\Include; ..\SYSTEM\StartUp; ..\SYSTEM; ..\Hardware\eeprom; ..\Hardware\spi_flash; ..\Hardware\nRF24; ..\Hardware\usb; ..\Hardware\stm32; ..\Hardware; ..\Board\CR4101; ..\Platform; ..\RTOS; ..\VMS; ..\GAP; ..\Core\inc; ..\Core\port; ..\ST\StdPeriph\inc; ..\ST\USB\Device\inc; ..\ST\USB\Driver\inc; ..\RTOS\FreeRTOS\v8.2.3\include; ..\RTOS\FreeRTOS\v8.2.3\portable\IAR\ARM_CM4F; ..\RTOS\FreeRTOS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\RTOS\FreeRTOS
  OBJCOPY.OOCOutputFile: CrabVMS-$CONFIG_NAME$.hex
  ILINK.IlinkOutputFile: CrabVMS-$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Board/CR4101
    ../Board/CR4101/: Hardware.c Hardware.h
  group Crab
    ../: CrabVMS.c CrabVMS.h
  group Crab/Core
    ../Core/Lib/: Crab.Core.Lite.CM4F.a
  group Crab/Core/inc
    ../Core/Inc/: CrabBaseType.h CrabDatetime.h CrabDefaultApi.h CrabErrorMsg.h CrabExecute.h CrabExtern.h CrabFifo.h CrabMath.h CrabStream.h CrabString.h CrabUtility.h
  group Crab/Core/port
    ../Core/Port/: CrabConfig.h CrabError.c CrabPlatform.h
  group Crab/Platform/inc
    ../Platform/: CrabAPI.h CrabEvent.h CrabHardware.h CrabStoreStream.h CrabUserApp.h CrabUserDebug.h
  group Crab/Platform/src
    ../Platform/: CrabAPI.c CrabEvent.c CrabHardware.c CrabStoreStream.c CrabUserApp.c CrabUserDebug.c
  group Crab/Platform/src/Default
    ../Platform/Default/: CrabStaticApi.c
  group Crab/Platform/src/STM32
    ../Platform/STM32/: CrabBoardApi.c CrabClock.c CrabPortable.c
  group Crab/Utility
    ../Utility/: CrabUtility.c CrabUtility.h
  group Crab/VMS/inc
    ../VMS/: CrabApplication.h CrabCommand.h CrabStorage.h CrabSystem.h CrabTask.h CrabVersionFW.h
  group Crab/VMS/src
    ../VMS/: CrabApplication.c CrabCommand.c CrabStorage.c CrabSystem.c CrabTask.c CrabTaskHook.c
  group FreeRTOS
    ../RTOS/FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/inc
    ../RTOS/FreeRTOS/v8.2.3/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/port
    ../RTOS/FreeRTOS/v8.2.3/portable/MemMang/: heap_3.c
    ../RTOS/FreeRTOS/v8.2.3/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group FreeRTOS/src
    ../RTOS/FreeRTOS/v8.2.3/: croutine.c list.c queue.c tasks.c timers.c
  group GAP
    ../GAP/: Gap.c Gap.h
  group HARDWARE
    ../Hardware/: stm32f4xx_it.c stm32f4xx_it.h
  group HARDWARE/eeprom
    ../Hardware/eeprom/: eeprom.c eeprom.h eepromCfg.h
  group HARDWARE/nRF24
    ../Hardware/nRF24/: nRF24L01.c nRF24L01.h nRF24L01Cfg.h
  group HARDWARE/spi_flash
    ../Hardware/spi_flash/: spiflash.c spiflash.h spiflashCfg.h
  group HARDWARE/stm32ext
    ../Hardware/stm32/: stm32ext.c stm32ext.h stm32gpio.h
  group HARDWARE/USB/inc
    ../Hardware/usb/: usb_conf.h usb_types.h usbd_conf.h usbd_desc.h usbd_gap.h
  group HARDWARE/USB/src
    ../Hardware/usb/: usb_bsp.c usbd_desc.c usbd_gap.c usbd_hw_init.c
  group ST/StdLib/inc
    ../ST/StdPeriph/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group ST/StdLib/src
    ../ST/StdPeriph/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ST/USB/core
    ../ST/USB/Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../ST/USB/Device/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group ST/USB/inc
    ../ST/USB/Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
    ../ST/USB/Device/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group SYSTEM
    ../System/: main.c
  group SYSTEM/START UP
    ../System/StartUp/: startup_stm32f40xx.s startup_stm32f4xx.s
  group SYSTEM/STM32-M4
    ../System/Include/: core_cm4.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
    ../System/Source/: system_stm32f4xx.c
